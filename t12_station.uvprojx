# Keil uVision project t12_station.uvprojx, settings and files
target T12_STM32F103C8_RTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: t12_station_rtos +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\bsp;.\hal\inc;.\app\inc;.\libraries\CMSIS;.\libraries\STM32F10x_StdPeriph_Driver\inc;.\middlewares;.\middlewares\FreeRTOS\include;.\middlewares\FreeRTOS\portable;.\middlewares\u8g2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./: main.c
    ./app/src/: app_ipc.c curve_fitting.c task_sensor_pid.c task_display.c ui_main.c ui_menu.c task_input_comm.c
  group BSP
    ./bsp/: bsp_board.c stm32f10x_it.c
  group HAL_DRV
    ./hal/src/: hal_adc.c hal_timer.c hal_i2c.c hal_flash.c hal_gpio.c hal_uart.c
  group CMSIS
    ./libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ./libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group STD_PERIPH_LIB
    ./libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group FREERTOS
    ./middlewares/FreeRTOS/src/: tasks.c queue.c list.c timers.c event_groups.c
    ./middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ./middlewares/FreeRTOS/portable/: port_auto.c
  group U8G2
    ./middlewares/u8g2/: u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x32.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u16toa.c u8x8_u8toa.c
